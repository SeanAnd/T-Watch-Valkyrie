#pragma once

#include <stddef.h>
#include <stdint.h>
#include <string.h>

namespace valkyrie
{

// First 3 bytes of Wi‑Fi / BLE addresses for Flock Safety infrastructure
// radios — same 31-prefix set as colonelpanichacks/flock-you (NitekryDPaul +
// DeFlockJoplin 82:6b:f2). Shared by BleClassifier (BLE OUI match) and the
// Wi‑Fi promiscuous path (flock-you addr1/addr2/wildcard-probe logic).

inline constexpr size_t kFlockInfraOuiCount = 31;

inline constexpr uint8_t kFlockInfraOui[kFlockInfraOuiCount][3] = {
    {0x70, 0xc9, 0x4e}, {0x3c, 0x91, 0x80}, {0xd8, 0xf3, 0xbc}, {0x80, 0x30, 0x49}, {0xb8, 0x35, 0x32}, {0x14, 0x5a, 0xfc},
    {0x74, 0x4c, 0xa1}, {0x08, 0x3a, 0x88}, {0x9c, 0x2f, 0x9d}, {0xc0, 0x35, 0x32}, {0x94, 0x08, 0x53}, {0xe4, 0xaa, 0xea},
    {0xf4, 0x6a, 0xdd}, {0xf8, 0xa2, 0xd6}, {0x24, 0xb2, 0xb9}, {0x00, 0xf4, 0x8d}, {0xd0, 0x39, 0x57}, {0xe8, 0xd0, 0xfc},
    {0xe0, 0x4f, 0x43}, {0xb8, 0x1e, 0xa4}, {0x70, 0x08, 0x94}, {0x58, 0x8e, 0x81}, {0xec, 0x1b, 0xbd}, {0x3c, 0x71, 0xbf},
    {0x58, 0x00, 0xe3}, {0x90, 0x35, 0xea}, {0x5c, 0x93, 0xa2}, {0x64, 0x6e, 0x69}, {0x48, 0x27, 0xea}, {0xa4, 0xcf, 0x12},
    {0x82, 0x6b, 0xf2},
};

inline bool macMatchesFlockInfraOui(const uint8_t *mac)
{
    if (!mac)
        return false;
    for (size_t i = 0; i < kFlockInfraOuiCount; ++i) {
        if (memcmp(mac, kFlockInfraOui[i], 3) == 0)
            return true;
    }
    return false;
}

} // namespace valkyrie
